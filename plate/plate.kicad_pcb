File: plate/plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 348.1 x 133.8 mm, 0 parts

Commit message: Actually draw out a plate
Other:
- board size 348.1 x 133.8 mm -> 338.1 x 143.8 mm
